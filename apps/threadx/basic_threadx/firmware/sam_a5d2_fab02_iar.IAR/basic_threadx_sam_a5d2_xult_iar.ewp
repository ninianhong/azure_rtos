# IAR project basic_threadx_sam_a5d2_xult_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMA5D27 Microchip ATSAMA5D27
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCDefines: FAB02; CONFIG_BOARD_SAMA5D2_FAB02
  ICCARM.PreInclude: Z:\lib-back\atmel-software-package\target\preinc.h
  ICCARM.CCIncludePath2: ..\src\third_party\rtos\threadx\common\inc; ..\src\third_party\rtos\threadx\ports\cortex_a5\iar\inc; ..\src\config\sam_a5d2_fab02_iar; ..\src\packs\ATSAMA5D27_DFP; ..\src\packs\CMSIS\CMSIS\Core_A\Include; ..\src\config\sam_a5d2_fab02_iar\threadx_config; ..\src; ..\src\third_party\rtos\threadx\common\inc; ..\..\..\..\..\..\threadx-usbx\common\core\inc; ..\..\..\..\..\..\threadx-usbx\ports\cortex_a5\iar\inc; ..\..\..\..\..\..\threadx-usbx\common\core\inc; ..\..\..\..\..\..\threadx-usbx\common\usbx_device_classes\inc; ..\..\..\..\..\..\threadx-usbx\common\usbx_host_controllers\inc; ..\..\..\..\..\..\threadx-usbx\common\usbx_host_classes\inc; Z:\lib-back\atmel-software-package\target\common; Z:\lib-back\atmel-software-package\target\sama5d2; Z:\lib-back\atmel-software-package\target\sama5d2\component; Z:\lib-back\atmel-software-package\target\sama5d2\pio; Z:\lib-back\atmel-software-package\target\sama5d2\toolchain\iar; Z:\lib-back\atmel-software-package\utils; Z:\lib-back\atmel-software-package\drivers; Z:\lib-back\atmel-software-package\drivers\peripherals; Z:\lib-back\atmel-software-package\arch
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\src\config\sam_a5d2_xult_iar\threadx_config; ..\src\third_party\rtos\threadx\common\inc; ..\src\third_party\rtos\threadx\ports\cortex_a5\iar\inc; .
  OBJCOPY.OOCOutputFile: harmony.bin
  ILINK.IlinkOutputFile: sam_a5d2_xult_iar.out
  ILINK.IlinkIcfFile: Z:\lib-back\azure_rtos\apps\threadx\basic_threadx\firmware\src\config\sam_a5d2_fab02_iar\ddr.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: ..\src\config\sam_a5d2_xult_iar\ddr.icf
  group (top)
    ../src/: main.c
  group Harmony3/atmel-target/common
    ../../../../../../atmel-software-package/target/common/: board_audio.c board_console.c board_led.c board_spi.c board_timer.c board_twi.c chip_common.c
  group Harmony3/atmel-target/sama5d2
    ../../../../../../atmel-software-package/target/sama5d2/: board_fab02.c board_support.c chip.c chip_pins.h sama5d2.h
  group Harmony3/Header Files
    ../src/: app.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar
    ../src/config/sam_a5d2_fab02_iar/: configuration.h definitions.h device.h device_cache.h interrupts.h toolchain_specifics.h user.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar/bsp
    ../src/config/sam_a5d2_fab02_iar/bsp/: bsp.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar/osal
    ../src/config/sam_a5d2_fab02_iar/osal/: osal.h osal_definitions.h osal_threadx.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar/peripheral/aic
    ../src/config/sam_a5d2_fab02_iar/peripheral/aic/: plib_aic.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar/peripheral/clk
    ../src/config/sam_a5d2_fab02_iar/peripheral/clk/: plib_clk.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar/peripheral/matrix
    ../src/config/sam_a5d2_fab02_iar/peripheral/matrix/: plib_matrix.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar/peripheral/mmu
    ../src/config/sam_a5d2_fab02_iar/peripheral/mmu/: plib_mmu.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar/peripheral/pio
    ../src/config/sam_a5d2_fab02_iar/peripheral/pio/: plib_pio.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar/peripheral/pit
    ../src/config/sam_a5d2_fab02_iar/peripheral/pit/: plib_pit.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar/system/cache
    ../src/config/sam_a5d2_fab02_iar/system/cache/: sys_cache.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar/threadx_config
    ../src/config/sam_a5d2_fab02_iar/threadx_config/: tx_user.h
  group Harmony3/Header Files/packs/ATSAMA5D27_DFP
    ../src/packs/ATSAMA5D27_DFP/: sama5d27.h
  group Harmony3/Header Files/packs/ATSAMA5D27_DFP/component
    ../src/packs/ATSAMA5D27_DFP/component/: acc.h adc.h aes.h aesb.h aic.h aximx.h chipid.h classd.h flexcom.h gmac.h i2sc.h icm.h isc.h l2cc.h lcdc.h matrix.h mcan.h mpddrc.h pdmic.h pio.h pit.h pmc.h ptc.h pwm.h qspi.h rstc.h rtc.h rxlp.h sckc.h sdmmc.h secumod.h sfc.h sfr.h sfrbu.h sha.h shdwc.h smc.h spi.h ssc.h tc.h tdes.h trng.h twihs.h uart.h udphs.h uhphs.h wdt.h xdmac.h
  group Harmony3/Header Files/packs/ATSAMA5D27_DFP/instance
    ../src/packs/ATSAMA5D27_DFP/instance/: acc.h adc.h aes.h aesb.h aic.h aximx.h chipid.h classd.h flexcom0.h flexcom1.h flexcom2.h flexcom3.h flexcom4.h gmac.h i2sc0.h i2sc1.h icm.h isc.h l2cc.h lcdc.h matrix0.h matrix1.h mcan0.h mcan1.h mpddrc.h pdmic.h pio.h pit.h pmc.h ptc.h pwm.h qspi0.h qspi1.h rstc.h rtc.h rxlp.h saic.h sckc.h sdmmc0.h sdmmc1.h secumod.h sfc.h sfr.h sfrbu.h sha.h shdwc.h smc.h spi0.h spi1.h ssc0.h ssc1.h tc0.h tc1.h tdes.h trng.h twihs0.h twihs1.h uart0.h uart1.h uart2.h uart3.h uart4.h udphs.h wdt.h xdmac0.h xdmac1.h
  group Harmony3/Header Files/packs/ATSAMA5D27_DFP/pio
    ../src/packs/ATSAMA5D27_DFP/pio/: sama5d27.h
  group Harmony3/Header Files/packs/CMSIS/CMSIS/Core_A/Include
    ../src/packs/CMSIS/CMSIS/Core_A/Include/: cmsis_compiler.h cmsis_cp15.h cmsis_gcc.h cmsis_iccarm.h core_ca.h
  group Harmony3/Header Files/threadx/common/inc
    ../src/third_party/rtos/threadx/common/inc/: tx_api.h tx_block_pool.h tx_byte_pool.h tx_event_flags.h tx_initialize.h tx_mutex.h tx_queue.h tx_semaphore.h tx_thread.h tx_timer.h tx_trace.h
  group Harmony3/Header Files/threadx/ports/cortex_a5/iar/inc
    ../src/third_party/rtos/threadx/ports/cortex_a5/iar/inc/: tx_port.h
  group Harmony3/lib-usb/core
    ../../../../../../threadx-usbx/common/core/src/: ux_dcd_sim_slave_address_set.c ux_dcd_sim_slave_endpoint_create.c ux_dcd_sim_slave_endpoint_destroy.c ux_dcd_sim_slave_endpoint_reset.c ux_dcd_sim_slave_endpoint_stall.c ux_dcd_sim_slave_endpoint_status.c ux_dcd_sim_slave_frame_number_get.c ux_dcd_sim_slave_function.c ux_dcd_sim_slave_initialize.c ux_dcd_sim_slave_initialize_complete.c ux_dcd_sim_slave_state_change.c ux_dcd_sim_slave_transfer_abort.c ux_dcd_sim_slave_transfer_request.c ux_dcd_sim_slave_transfer_run.c ux_device_class_dpump_activate.c ux_device_class_dpump_change.c ux_device_class_dpump_deactivate.c ux_device_class_dpump_entry.c ux_device_class_dpump_initialize.c ux_device_class_dpump_read.c ux_device_class_dpump_read_run.c ux_device_class_dpump_thread.c ux_device_class_dpump_write.c ux_device_class_dpump_write_run.c ux_device_stack_alternate_setting_get.c ux_device_stack_alternate_setting_set.c ux_device_stack_class_register.c ux_device_stack_class_unregister.c ux_device_stack_clear_feature.c ux_device_stack_configuration_get.c ux_device_stack_configuration_set.c ux_device_stack_control_request_process.c ux_device_stack_descriptor_send.c ux_device_stack_disconnect.c ux_device_stack_endpoint_stall.c ux_device_stack_get_status.c ux_device_stack_host_wakeup.c ux_device_stack_initialize.c ux_device_stack_interface_delete.c ux_device_stack_interface_get.c ux_device_stack_interface_set.c ux_device_stack_interface_start.c ux_device_stack_microsoft_extension_register.c ux_device_stack_tasks_run.c ux_device_stack_transfer_abort.c ux_device_stack_transfer_all_request_abort.c ux_device_stack_transfer_request.c ux_device_stack_transfer_run.c ux_device_stack_uninitialize.c ux_hcd_sim_host_asynch_queue_process.c ux_hcd_sim_host_asynch_schedule.c ux_hcd_sim_host_asynchronous_endpoint_create.c ux_hcd_sim_host_asynchronous_endpoint_destroy.c ux_hcd_sim_host_controller_disable.c ux_hcd_sim_host_ed_obtain.c ux_hcd_sim_host_ed_td_clean.c ux_hcd_sim_host_endpoint_reset.c ux_hcd_sim_host_entry.c ux_hcd_sim_host_frame_number_get.c ux_hcd_sim_host_frame_number_set.c ux_hcd_sim_host_initialize.c ux_hcd_sim_host_interrupt_endpoint_create.c ux_hcd_sim_host_iso_queue_process.c ux_hcd_sim_host_iso_schedule.c ux_hcd_sim_host_isochronous_endpoint_create.c ux_hcd_sim_host_isochronous_td_obtain.c ux_hcd_sim_host_least_traffic_list_get.c ux_hcd_sim_host_periodic_endpoint_destroy.c ux_hcd_sim_host_periodic_schedule.c ux_hcd_sim_host_periodic_tree_create.c ux_hcd_sim_host_port_reset.c ux_hcd_sim_host_port_status_get.c ux_hcd_sim_host_regular_td_obtain.c ux_hcd_sim_host_request_control_transfer.c ux_hcd_sim_host_request_interupt_transfer.c ux_hcd_sim_host_request_isochronous_transfer.c ux_hcd_sim_host_request_transfer.c ux_hcd_sim_host_timer_function.c ux_hcd_sim_host_transaction_schedule.c ux_hcd_sim_host_transfer_abort.c ux_hcd_sim_host_transfer_run.c ux_hcd_sim_host_uninitialize.c ux_host_class_dpump_activate.c ux_host_class_dpump_configure.c ux_host_class_dpump_deactivate.c ux_host_class_dpump_endpoints_get.c ux_host_class_dpump_entry.c ux_host_class_dpump_ioctl.c ux_host_class_dpump_read.c ux_host_class_dpump_write.c ux_host_stack_bandwidth_check.c ux_host_stack_bandwidth_claim.c ux_host_stack_bandwidth_release.c ux_host_stack_class_call.c ux_host_stack_class_device_scan.c ux_host_stack_class_get.c ux_host_stack_class_instance_create.c ux_host_stack_class_instance_destroy.c ux_host_stack_class_instance_get.c ux_host_stack_class_instance_verify.c ux_host_stack_class_interface_scan.c ux_host_stack_class_register.c ux_host_stack_class_unregister.c ux_host_stack_configuration_descriptor_parse.c ux_host_stack_configuration_enumerate.c ux_host_stack_configuration_instance_create.c ux_host_stack_configuration_instance_delete.c ux_host_stack_configuration_interface_get.c ux_host_stack_configuration_interface_scan.c ux_host_stack_configuration_set.c ux_host_stack_delay_ms.c ux_host_stack_device_address_set.c ux_host_stack_device_configuration_activate.c ux_host_stack_device_configuration_deactivate.c ux_host_stack_device_configuration_get.c ux_host_stack_device_configuration_reset.c ux_host_stack_device_configuration_select.c ux_host_stack_device_descriptor_read.c ux_host_stack_device_get.c ux_host_stack_device_remove.c ux_host_stack_device_resources_free.c ux_host_stack_device_string_get.c ux_host_stack_endpoint_instance_create.c ux_host_stack_endpoint_instance_delete.c ux_host_stack_endpoint_reset.c ux_host_stack_endpoint_transfer_abort.c ux_host_stack_enum_thread_entry.c ux_host_stack_hcd_register.c ux_host_stack_hcd_thread_entry.c ux_host_stack_hcd_transfer_request.c ux_host_stack_hcd_unregister.c ux_host_stack_hnp_polling_thread_entry.c ux_host_stack_initialize.c ux_host_stack_interface_endpoint_get.c ux_host_stack_interface_instance_create.c ux_host_stack_interface_instance_delete.c ux_host_stack_interface_set.c ux_host_stack_interface_setting_select.c ux_host_stack_interfaces_scan.c ux_host_stack_new_configuration_create.c ux_host_stack_new_device_create.c ux_host_stack_new_device_get.c ux_host_stack_new_endpoint_create.c ux_host_stack_new_interface_create.c ux_host_stack_rh_change_process.c ux_host_stack_rh_device_extraction.c ux_host_stack_rh_device_insertion.c ux_host_stack_role_swap.c ux_host_stack_tasks_run.c ux_host_stack_transfer_request.c ux_host_stack_transfer_request_abort.c ux_host_stack_transfer_run.c ux_host_stack_uninitialize.c ux_system_error_handler.c ux_system_initialize.c ux_system_tasks_run.c ux_system_uninitialize.c ux_trace_event_insert.c ux_trace_event_update.c ux_trace_object_register.c ux_trace_object_unregister.c ux_utility_debug_callback_register.c ux_utility_debug_log.c ux_utility_delay_ms.c ux_utility_descriptor_pack.c ux_utility_descriptor_parse.c ux_utility_error_callback_register.c ux_utility_event_flags_create.c ux_utility_event_flags_delete.c ux_utility_event_flags_get.c ux_utility_event_flags_set.c ux_utility_long_get.c ux_utility_long_get_big_endian.c ux_utility_long_put.c ux_utility_long_put_big_endian.c ux_utility_memory_allocate.c ux_utility_memory_allocate_add_safe.c ux_utility_memory_allocate_mulc_safe.c ux_utility_memory_allocate_mulv_safe.c ux_utility_memory_compare.c ux_utility_memory_copy.c ux_utility_memory_free.c ux_utility_memory_free_block_best_get.c ux_utility_memory_set.c ux_utility_mutex_create.c ux_utility_mutex_delete.c ux_utility_mutex_off.c ux_utility_mutex_on.c ux_utility_pci_class_scan.c ux_utility_pci_read.c ux_utility_pci_write.c ux_utility_physical_address.c ux_utility_semaphore_create.c ux_utility_semaphore_delete.c ux_utility_semaphore_get.c ux_utility_semaphore_put.c ux_utility_set_interrupt_handler.c ux_utility_short_get.c ux_utility_short_get_big_endian.c ux_utility_short_put.c ux_utility_short_put_big_endian.c ux_utility_string_length_check.c ux_utility_string_length_get.c ux_utility_string_to_unicode.c ux_utility_thread_create.c ux_utility_thread_delete.c ux_utility_thread_identify.c ux_utility_thread_relinquish.c ux_utility_thread_resume.c ux_utility_thread_schedule_other.c ux_utility_thread_sleep.c ux_utility_thread_suspend.c ux_utility_timer_create.c ux_utility_timer_delete.c ux_utility_unicode_to_string.c ux_utility_virtual_address.c
  group Harmony3/lib-usb/usbx_device_classes
    ../../../../../../threadx-usbx/common/usbx_device_classes/src/: ux_device_class_cdc_acm_activate.c ux_device_class_cdc_acm_bulkin_thread.c ux_device_class_cdc_acm_bulkout_thread.c ux_device_class_cdc_acm_control_request.c ux_device_class_cdc_acm_deactivate.c ux_device_class_cdc_acm_entry.c ux_device_class_cdc_acm_initialize.c ux_device_class_cdc_acm_ioctl.c ux_device_class_cdc_acm_read.c ux_device_class_cdc_acm_read_run.c ux_device_class_cdc_acm_tasks_run.c ux_device_class_cdc_acm_unitialize.c ux_device_class_cdc_acm_write.c ux_device_class_cdc_acm_write_run.c ux_device_class_cdc_acm_write_with_callback.c
  group Harmony3/lib-usb/usbx_host_classes
    ../../../../../../threadx-usbx/common/usbx_host_classes/src/: ux_host_class_cdc_acm_activate.c ux_host_class_cdc_acm_capabilities_get.c ux_host_class_cdc_acm_command.c ux_host_class_cdc_acm_configure.c ux_host_class_cdc_acm_deactivate.c ux_host_class_cdc_acm_endpoints_get.c ux_host_class_cdc_acm_entry.c ux_host_class_cdc_acm_ioctl.c ux_host_class_cdc_acm_nnh.c ux_host_class_cdc_acm_read.c ux_host_class_cdc_acm_reception_callback.c ux_host_class_cdc_acm_reception_start.c ux_host_class_cdc_acm_reception_stop.c ux_host_class_cdc_acm_transfer_request_completed.c ux_host_class_cdc_acm_transmission_callback.c ux_host_class_cdc_acm_write.c
  group Harmony3/lib-usb/usbx_host_controllers
    ../../../../../../threadx-usbx/common/usbx_host_controllers/src/: ux_hcd_ehci_asynch_td_process.c ux_hcd_ehci_asynchronous_endpoint_create.c ux_hcd_ehci_asynchronous_endpoint_destroy.c ux_hcd_ehci_controller_disable.c ux_hcd_ehci_done_queue_process.c ux_hcd_ehci_door_bell_wait.c ux_hcd_ehci_ed_clean.c ux_hcd_ehci_ed_obtain.c ux_hcd_ehci_endpoint_reset.c ux_hcd_ehci_entry.c ux_hcd_ehci_frame_number_get.c ux_hcd_ehci_frame_number_set.c ux_hcd_ehci_fsisochronous_td_obtain.c ux_hcd_ehci_fsisochronous_tds_process.c ux_hcd_ehci_hsisochronous_td_obtain.c ux_hcd_ehci_hsisochronous_tds_process.c ux_hcd_ehci_initialize.c ux_hcd_ehci_interrupt_endpoint_create.c ux_hcd_ehci_interrupt_endpoint_destroy.c ux_hcd_ehci_interrupt_handler.c ux_hcd_ehci_isochronous_endpoint_create.c ux_hcd_ehci_isochronous_endpoint_destroy.c ux_hcd_ehci_least_traffic_list_get.c ux_hcd_ehci_next_td_clean.c ux_hcd_ehci_periodic_descriptor_link.c ux_hcd_ehci_periodic_tree_create.c ux_hcd_ehci_poll_rate_entry_get.c ux_hcd_ehci_port_disable.c ux_hcd_ehci_port_reset.c ux_hcd_ehci_port_resume.c ux_hcd_ehci_port_status_get.c ux_hcd_ehci_port_suspend.c ux_hcd_ehci_power_down_port.c ux_hcd_ehci_power_on_port.c ux_hcd_ehci_power_root_hubs.c ux_hcd_ehci_register_read.c ux_hcd_ehci_register_write.c ux_hcd_ehci_regular_td_obtain.c ux_hcd_ehci_request_bulk_transfer.c ux_hcd_ehci_request_control_transfer.c ux_hcd_ehci_request_interrupt_transfer.c ux_hcd_ehci_request_isochronous_transfer.c ux_hcd_ehci_request_transfer.c ux_hcd_ehci_request_transfer_add.c ux_hcd_ehci_transfer_abort.c ux_hcd_ehci_transfer_request_process.c ux_hcd_ohci_asynchronous_endpoint_create.c ux_hcd_ohci_asynchronous_endpoint_destroy.c ux_hcd_ohci_controller_disable.c ux_hcd_ohci_done_queue_process.c ux_hcd_ohci_ed_obtain.c ux_hcd_ohci_endpoint_error_clear.c ux_hcd_ohci_endpoint_reset.c ux_hcd_ohci_entry.c ux_hcd_ohci_frame_number_get.c ux_hcd_ohci_frame_number_set.c ux_hcd_ohci_initialize.c ux_hcd_ohci_interrupt_endpoint_create.c ux_hcd_ohci_interrupt_handler.c ux_hcd_ohci_isochronous_endpoint_create.c ux_hcd_ohci_isochronous_td_obtain.c ux_hcd_ohci_least_traffic_list_get.c ux_hcd_ohci_next_td_clean.c ux_hcd_ohci_periodic_endpoint_destroy.c ux_hcd_ohci_periodic_tree_create.c ux_hcd_ohci_port_disable.c ux_hcd_ohci_port_enable.c ux_hcd_ohci_port_reset.c ux_hcd_ohci_port_resume.c ux_hcd_ohci_port_status_get.c ux_hcd_ohci_port_suspend.c ux_hcd_ohci_power_down_port.c ux_hcd_ohci_power_on_port.c ux_hcd_ohci_power_root_hubs.c ux_hcd_ohci_register_read.c ux_hcd_ohci_register_write.c ux_hcd_ohci_regular_td_obtain.c ux_hcd_ohci_request_bulk_transfer.c ux_hcd_ohci_request_control_transfer.c ux_hcd_ohci_request_interupt_transfer.c ux_hcd_ohci_request_isochronous_transfer.c ux_hcd_ohci_request_transfer.c ux_hcd_ohci_transfer_abort.c ux_hcd_ohci_transfer_request_process.c
  group Harmony3/Linker File
    ../src/config/sam_a5d2_fab02_iar/: ddr.icf
  group Harmony3/Source Files/config/sam_a5d2_xult_iar
    ../src/config/sam_a5d2_fab02_iar/: cstartup.s fault_handlers.c initialization.c interrupts.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar/bsp
    ../src/config/sam_a5d2_fab02_iar/bsp/: bsp.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar/osal
    ../src/config/sam_a5d2_fab02_iar/osal/: osal_threadx.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar/peripheral/aic
    ../src/config/sam_a5d2_fab02_iar/peripheral/aic/: plib_aic.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar/peripheral/clk
    ../src/config/sam_a5d2_fab02_iar/peripheral/clk/: plib_clk.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar/peripheral/matrix
    ../src/config/sam_a5d2_fab02_iar/peripheral/matrix/: plib_matrix.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar/peripheral/mmu
    ../src/config/sam_a5d2_fab02_iar/peripheral/mmu/: plib_mmu.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar/peripheral/pio
    ../src/config/sam_a5d2_fab02_iar/peripheral/pio/: plib_pio.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar/peripheral/pit
    ../src/config/sam_a5d2_fab02_iar/peripheral/pit/: plib_pit.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar/stdio
    ../src/config/sam_a5d2_fab02_iar/stdio/: iar_monitor.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar/system/cache
    ../src/config/sam_a5d2_fab02_iar/system/cache/: sys_cache.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar/threadx_config
    ../src/config/sam_a5d2_fab02_iar/threadx_config/: sama5d2_tx_port.s sama5d2_tx_timer.c
  group Harmony3/Source Files/threadx/common/src
    ../src/third_party/rtos/threadx/common/src/: tx_block_allocate.c tx_block_pool_cleanup.c tx_block_pool_create.c tx_block_pool_delete.c tx_block_pool_info_get.c tx_block_pool_initialize.c tx_block_pool_performance_info_get.c tx_block_pool_performance_system_info_get.c tx_block_pool_prioritize.c tx_block_release.c tx_byte_allocate.c tx_byte_pool_cleanup.c tx_byte_pool_create.c tx_byte_pool_delete.c tx_byte_pool_info_get.c tx_byte_pool_initialize.c tx_byte_pool_performance_info_get.c tx_byte_pool_performance_system_info_get.c tx_byte_pool_prioritize.c tx_byte_pool_search.c tx_byte_release.c tx_event_flags_cleanup.c tx_event_flags_create.c tx_event_flags_delete.c tx_event_flags_get.c tx_event_flags_info_get.c tx_event_flags_initialize.c tx_event_flags_performance_info_get.c tx_event_flags_performance_system_info_get.c tx_event_flags_set.c tx_event_flags_set_notify.c tx_initialize_high_level.c tx_initialize_kernel_enter.c tx_initialize_kernel_setup.c tx_misra.c tx_mutex_cleanup.c tx_mutex_create.c tx_mutex_delete.c tx_mutex_get.c tx_mutex_info_get.c tx_mutex_initialize.c tx_mutex_performance_info_get.c tx_mutex_performance_system_info_get.c tx_mutex_prioritize.c tx_mutex_priority_change.c tx_mutex_put.c tx_queue_cleanup.c tx_queue_create.c tx_queue_delete.c tx_queue_front_send.c tx_queue_info_get.c tx_queue_initialize.c tx_queue_performance_info_get.c tx_queue_performance_system_info_get.c tx_queue_prioritize.c tx_queue_receive.c tx_queue_send.c tx_queue_send_notify.c tx_semaphore_ceiling_put.c tx_semaphore_cleanup.c tx_semaphore_create.c tx_semaphore_delete.c tx_semaphore_get.c tx_semaphore_info_get.c tx_semaphore_initialize.c tx_semaphore_performance_info_get.c tx_semaphore_performance_system_info_get.c tx_semaphore_prioritize.c tx_semaphore_put.c tx_semaphore_put_notify.c tx_thread_create.c tx_thread_delete.c tx_thread_entry_exit_notify.c tx_thread_identify.c tx_thread_info_get.c tx_thread_initialize.c tx_thread_performance_info_get.c tx_thread_performance_system_info_get.c tx_thread_preemption_change.c tx_thread_priority_change.c tx_thread_relinquish.c tx_thread_reset.c tx_thread_resume.c tx_thread_shell_entry.c tx_thread_sleep.c tx_thread_stack_analyze.c tx_thread_stack_error_handler.c tx_thread_stack_error_notify.c tx_thread_suspend.c tx_thread_system_preempt_check.c tx_thread_system_resume.c tx_thread_system_suspend.c tx_thread_terminate.c tx_thread_time_slice.c tx_thread_time_slice_change.c tx_thread_timeout.c tx_thread_wait_abort.c tx_time_get.c tx_time_set.c tx_timer_activate.c tx_timer_change.c tx_timer_create.c tx_timer_deactivate.c tx_timer_delete.c tx_timer_expiration_process.c tx_timer_info_get.c tx_timer_initialize.c tx_timer_performance_info_get.c tx_timer_performance_system_info_get.c tx_timer_system_activate.c tx_timer_system_deactivate.c tx_timer_thread_entry.c tx_trace_buffer_full_notify.c tx_trace_disable.c tx_trace_enable.c tx_trace_event_filter.c tx_trace_event_unfilter.c tx_trace_initialize.c tx_trace_interrupt_control.c tx_trace_isr_enter_insert.c tx_trace_isr_exit_insert.c tx_trace_object_register.c tx_trace_object_unregister.c tx_trace_user_event_insert.c txe_block_allocate.c txe_block_pool_create.c txe_block_pool_delete.c txe_block_pool_info_get.c txe_block_pool_prioritize.c txe_block_release.c txe_byte_allocate.c txe_byte_pool_create.c txe_byte_pool_delete.c txe_byte_pool_info_get.c txe_byte_pool_prioritize.c txe_byte_release.c txe_event_flags_create.c txe_event_flags_delete.c txe_event_flags_get.c txe_event_flags_info_get.c txe_event_flags_set.c txe_event_flags_set_notify.c txe_mutex_create.c txe_mutex_delete.c txe_mutex_get.c txe_mutex_info_get.c txe_mutex_prioritize.c txe_mutex_put.c txe_queue_create.c txe_queue_delete.c txe_queue_flush.c txe_queue_front_send.c txe_queue_info_get.c txe_queue_prioritize.c txe_queue_receive.c txe_queue_send.c txe_queue_send_notify.c txe_semaphore_ceiling_put.c txe_semaphore_delete.c txe_semaphore_get.c txe_semaphore_info_get.c txe_semaphore_prioritize.c txe_semaphore_put.c txe_semaphore_put_notify.c txe_thread_create.c txe_thread_delete.c txe_thread_entry_exit_notify.c txe_thread_info_get.c txe_thread_preemption_change.c txe_thread_priority_change.c txe_thread_relinquish.c txe_thread_reset.c txe_thread_resume.c txe_thread_suspend.c txe_thread_terminate.c txe_thread_time_slice_change.c txe_thread_wait_abort.c txe_timer_activate.c txe_timer_change.c txe_timer_create.c txe_timer_deactivate.c txe_timer_delete.c txe_timer_info_get.c
  group Harmony3/Source Files/threadx/ports/cortex_a5/iar/src
    ../src/third_party/rtos/threadx/ports/cortex_a5/iar/src/: tx_iar.c tx_initialize_low_level.s tx_thread_context_restore.s tx_thread_context_save.s tx_thread_fiq_context_restore.s tx_thread_fiq_context_save.s tx_thread_fiq_nesting_end.s tx_thread_fiq_nesting_start.s tx_thread_interrupt_control.s tx_thread_interrupt_disable.s tx_thread_interrupt_restore.s tx_thread_irq_nesting_end.s tx_thread_irq_nesting_start.s tx_thread_schedule.s tx_thread_stack_build.s tx_thread_system_return.s tx_thread_vectored_context_save.s tx_timer_interrupt.s
  group Harmony3/task
    ../src/: app.c
    ../../../../../../threadx-usbx/samples/: demo_usbx.c
    ../src/config/sam_a5d2_xult_iar/: task_led.c
